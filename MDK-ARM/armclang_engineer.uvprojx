# Keil uVision project armclang_engineer.uvprojx, settings and files
target armclang_engineer (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: armclang_engineer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=9 wLevel=1
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Own/App;../Own/App/Imu/BMI088/inc;../Own/Bsp;../Own/Mod;../Own/Obj;../Own/OperateSystem
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: armclang_engineer\armclang_engineer.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c bdma.c dma.c fdcan.c memorymap.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Own/App
    ../Own/App/Buzzer/: Buzzer.cpp
    ../Own/App/Imu/: Imu.cpp
    ../Own/App/MicroTime/: MicroTime.cpp
    ../Own/App/Motor/: dmMotor.cpp GM6020.cpp
    ../Own/App/Pump/: Pump.cpp
    ../Own/App/RemoteControl/: RemoteControl.cpp remote_ctrl_dep.cpp
    ../Own/App/RGBLED/: RGBLED.cpp
    ../Own/App/W25Q64/: W25Q64.cpp
    ../Own/App/Judge/: referee_system.cpp ui.cpp
    ../Own/App/ImageTrans/: ImageTrans.cpp
    ../Own/App/SubBoard/: SubBoard.cpp
  group Own/Bsp
    ../Own/Bsp/CAN/: SuperCan.cpp
    ../Own/Bsp/CDC/: SuperCDC.cpp
    ../Own/Bsp/GPIO/: SuperGPIO.cpp
    ../Own/Bsp/SPI/: SuperSPI.cpp
    ../Own/Bsp/Uart/: SuperUart.cpp
    ../Own/Bsp/WDG/: SuperIWDG.cpp
  group Own/Callback
    ../Own/CallBack/: CanCallback.cpp CDCCallback.cpp GPIOCallback.cpp SPICallback.cpp UARTCallback.cpp KeyCallback.cpp
  group Own/Mod
    ../Own/Mod/Crc/: Crc.cpp
    ../Own/Mod/Detect/: Detect.cpp DetectManager.cpp
    ../Own/Mod/DoubleBuffer/: DoubleBuffer.cpp
    ../Own/Mod/Filter/: Filter.cpp RoundQueue.cpp
    ../Own/Mod/Key/: Key.cpp
    ../Own/Mod/Matrix/: Matrix.cpp
    ../Own/Mod/MyMath/: MyMath.cpp
    ../Own/Mod/Pid/: DoublePid.cpp Pid.cpp
    ../Own/Mod/Slope/: Slope.cpp
  group Own/Obj
    ../Own/Obj/Chassis/: Chassis.cpp chassis_dep.cpp
    ../Own/Obj/RoboArm/: RoboArm.cpp roboarm_dep.cpp
    ../Own/Obj/Interact/: Interact.cpp interact_dep.cpp
  group Own/OperateSystem
    ../Own/OperateSystem/Heap/: rtx_memory.c CustomHeap.cpp Redifine.cpp
    ../Own/OperateSystem/Port/: CppPort.cpp
  group Own/OperateSystem/Task
    ../Own/OperateSystem/: Thread.cpp Vari.cpp
    ../Own/OperateSystem/Thread/: ChassisTask.cpp DetectTask.cpp DJITask.cpp ErrorTask.cpp IMUTask.cpp LedTask.cpp LKTask.cpp PCTask.cpp RemoteCtrlTask.cpp StartTask.cpp ImageTransTask.cpp JudgeTask.cpp TransmitTask.cpp KbTask.cpp UITask.cpp ArmInitTask.cpp
  group Own/App/Imu
    ../Own/App/Imu/Mahony/: MahonyAHRS.c
    ../Own/App/Imu/BMI088/: BMI088driver.c BMI088Middleware.c bsp_dwt.c
    ../Own/App/Imu/Algorithm/: controller.c kalman_filter.c QuaternionEKF.c user_lib.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
